Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Projet VRD 8.0.2
Time: 2015-11-03T09:59:44
Made in: IfcPlusPlus

# IfcBuildingElementProxy, TN Fondations
In: VRD
PSET-MENSURA - Nom Surface MNT: TN Fondations; Surface Horizontale: 11747.7 m2; Surface Selon la pente: 12013.5 m2; Valeur décapage générale: 0 m
