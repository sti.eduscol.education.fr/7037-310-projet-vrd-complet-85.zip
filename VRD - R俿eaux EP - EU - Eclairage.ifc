Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Projet VRD 9.0
Time: 2015-11-20T09:32:42
Made in: IfcPlusPlus

# IfcFlowFitting (24)
In: Niveau
PSET-MENSURA - Profondeur: Non disponible; Hauteur de décantation: 0 m; Catalogue Fourniture: Bdd noeuds GENIUS_2; Element droit: Non disponible; Element de fond: Non disponible
Name | Numéro | Type de regard = Group | X (m) | Y (m) | Z tampon (m) | Zfe 1 (m) | Zfe n...
 | R1 | 3.Grille carrée | 3.66135 | -33.5691 | 0.51398 | -0.48602
 | R2 | 3.Grille carrée | 33.6509 | -24.2873 | -0.228757 | -1.38241 | -1.38
 | R3 | 3.Grille carrée | 24.1331 | -14.4585 | -0.77308 | -2.53947 | -1.77 -2.54
 | R4 | 1.Visite | 19.1508 | -14.4038 | -0.743992 | -2.45352 | -1.70 -2.45
 | R5 | 1.Visite | 37.3554 | -8.24434 | -0.34482 | -2.79149 | -2.79 -1.34
 | R6 | 5.Noeud | 48.9626 | -10.1606 | -0.994416 | -2.99442
 | R7 | 1.Visite | 37.4053 | -2.04403 | 0 | -1.20187 | -1.18 -1.20
 | R8 | 2.Brancht | 46.3619 | 2.1583 | 0 | -0.973769 | -0.97
 | R9 | 2.Brancht | 51.3716 | 22.0876 | 0 | -0.5
 | R10 | 2.Brancht | -2.6351 | 25.9987 | 0 | -0.5
 | R11 | 2.Brancht | -2.55736 | -2.12251 | 0 | -0.781214 | -0.78
 | R12 | 3.Grille carrée | -21.8364 | 9.69779 | -0.326854 | -1.32685
 | R13 | 3.Grille carrée | -21.6654 | -14.7965 | -0.663062 | -1.74938 | -1.75
 | R14 | 3.Grille carrée | -7.96819 | -14.8612 | -0.547617 | -1.98566 | -1.99
 | R15 | 3.Grille carrée | 17.5083 | -15.5809 | -0.682771 | -1.68277
 | R23 | 1.Visite | 36.0686 | -0.524863 | 0 | -0.9
 | R24 | 1.Visite | 35.7802 | -9.80256 | -0.331256 | -0.9 | -0.90
 | R25 | 5.Noeud | 48.2871 | -11.9649 | -0.737972 | -1.73797
 | R17 | Eclairage | -0.787844 | -46.5299 | 0.52 | -1.46943 | -1.47 | PSET-MENSURA - Tampon: Mat 3.5m
 | R18 | Eclairage | 8.10885 | -33.0148 | 0.501835 | -1.46943 | -1.47 | PSET-MENSURA - Tampon: Mat 3.5m
 | R19 | Eclairage | 22.3644 | -14.8743 | -0.789766 | -1.46943 | -1.47 | PSET-MENSURA - Tampon: Mat 3.5m
 | R21 | Eclairage | -22.42 | -34.0049 | 0.0336675 | -0.966333 | PSET-MENSURA - Tampon: Mat 3.5m
 | R22 | 5.Noeud | -23.1223 | -34.0049 | -0.00464207 | -0.966333 | -0.97 -0.97
 | R27 | Eclairage | -22.4477 | -4.02815 | -0.407882 | -1.40788 | PSET-MENSURA - Tampon: Mat 3.5m

# IfcFlowSegment (22)
In: Niveau
PSET-MENSURA - Regard/Noeud Amont: Non disponible; Regard/Noeud Aval: Non disponible; Epaisseur collecteur: Non disponible; Longueur Hors tout: 0 m; Poids (kg): 0 kg; Diamètre Forage: 0 mm; Référence imposée: Non; Tronçon existant: Non
Name | Type de réseaux = Group | Type Collecteur | Gamme | Diamètre de référence (mm) (mm) | Longeur tronçon (m) | Pente % | Diamètre intérieur (mm) | Longueur utile (m) | Rugosité : Coef de Bazin | Rugosité : Coef Manning Stickler | Rugosité : Coef Colebrook White
 | EP | PVC CR8 EP | PVC | 200 | 31.4059 | 2.85538 | 183 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 250 | 13.6874 | 2.85538 | 229 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 250 | 4.98336 | 1.72498 | 229 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 315 | 14.612 | 1.72497 | 289 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 400 | 11.766 | 1.72498 | 366 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 200 | 6.20215 | 2.30552 | 183 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 160 | 9.89612 | 2.30553 | 146 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 160 | 20.5547 | 2.30553 | 146 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 160 | 28.1228 | 1 | 146 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 160 | 39.9647 | 1 | 146 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 200 | 24.4985 | 1.72497 | 183 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 250 | 13.6995 | 1.72497 | 229 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 250 | 27.1269 | 1.72497 | 229 | 6 | 0.06 | 90 | 0.54
 | EP | PVC CR8 EP | PVC | 250 | 2.02088 | 0.999962 | 229 | 6 | 0.06 | 90 | 0.54
 | EU | PVC CR8 EU | Autre | 200 | 9.28218 | 0 | 183 | 6 | 0.06 | 90 | 0.54
 | EU | PVC CR8 EU | Autre | 200 | 12.7201 | 6.60213 | 183 | 6 | 0.06 | 90 | 0.54
 | Electricité | Elec-Fourreaux-TPC | Autre | 0 | 16.1805 | 0 | 0 | 0 | 0.25 | 70 | 2.44
 | Electricité | Elec-Fourreaux-TPC | Autre | 0 | 23.0716 | 0 | 0 | 0 | 0.25 | 70 | 2.44
 | Electricité | Elec-Fourreaux-TPC | Autre | 0 | 0.702278 | 0 | 0 | 0 | 0.25 | 70 | 2.44
 | Electricité | Elec-Fourreaux-TPC | Autre | 0 | 71.5816 | 0 | 0 | 0 | 0.25 | 70 | 2.44
 | Electricité | Elec-Fourreaux-TPC | Autre | 0 | 30.192 | 1.46263 | 0 | 0 | 0.25 | 70 | 2.44
 | Electricité | Elec-Fourreaux-TPC | Autre | 0 | 41.3132 | 1.21786 | 0 | 0 | 0.25 | 70 | 2.44
