Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Projet VRD 8.0.2
Time: 2015-11-03T09:59:18
Made in: IfcPlusPlus

# IfcBuildingElementProxy (4)
In: VRD
Name | Nom Couche Géologique
Terrain_Terre végétale | Terre végétale
Terrain_Mort Terrain | Mort Terrain
Terrain_Roc | Roc
Terrain | PSET-MENSURA - Nom Surface MNT: Terrain; Surface Horizontale: 11621.4 m2; Surface Selon la pente: 11759.4 m2; Valeur décapage générale: 0 m
